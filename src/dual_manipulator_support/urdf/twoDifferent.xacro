Commit message: pre exam

File: src/dual_manipulator_support/urdf/twoDifferent.xacro (robot description, xacro)
@@ -11,4 +11,5 @@
       </geometry>
       <origin xyz="0 0 0" rpy="0 0 0"/>
+      <material name="white"/>
     </visual>
     <collision>
